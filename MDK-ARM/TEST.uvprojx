# Keil uVision project TEST.uvprojx, settings and files
target TEST (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: TEST +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,USE_USB_FS
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\FATFS\src;..\USB\STM32_USB_Host_Library\Core\Inc;..\USB;..\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\FATFS\exfuns;..\Chinese;..\TOUCH;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;..\Drivers\CMSIS\DSP\Include;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\DEMO;..\EMWIN\tsst;..\EMWIN\STemWinHZ;..\EMWIN\HZDEMO;..\EMWIN\JPEG;..\EMWIN\EMWIN_PICTURE\BMP;..\EMWIN\EMWIN_PICTURE\GIF;..\EMWIN\EMWIN_PICTURE\JPEG;..\EMWIN\EMWIN_PICTURE\PNG;..\EMWIN;..\EMWIN\STemWinPNG;..\EMWIN\KEYPAD;..\T9INPUT
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Application/User
    ../Src/: key.c sdram.c w25q256.c malloc.c gfxsimulator.c mpu.c myiic.c delay.c pcf8574.c main.c gpio.c dma.c freertos.c ltdc.c quadspi.c sdmmc.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c crc.c rgblcd.c led.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_cortex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_qspi.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_jpeg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group LCD_HZ
    ../Chinese/: fontupd.c text_zh.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c ffsystem.c ffunicode.c
    ../FATFS/exfuns/: exfuns.c
  group USB_CORE
    ../USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USB_HOST
    ../USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group USB_APP
    ../USB/: usbh_conf.c usbh_diskio_dma.c
  group TOUCH
    ../TOUCH/: ctiic.c gt9147.c
  group T9INPUT
    ../T9INPUT/: pyinput.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group ENWIN_LIB
    ../EMWIN/STemWin/Lib/: STemWin_CM7_OS_wc16.a STemWin_CM7_wc16.a STemWin_CM7_wc16_ot_ARGB.a STemWin_CM7_wc16_ot.a STemWin_CM7_wc16_ARGB.a GUI_CM4F_L.lib STemWin_CM7_OS_wc16_ot_ARGB.a STemWin_CM7_OS_wc16_ot.a
  group EMWIN_CONFIG
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf_Lin_Template.c
    ../EMWIN/STemWin/OS/: GUI_X_FreeRTOS.c
  group EMWIN_HZ
    ../EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c Hzfontupdata.c
  group EMWIN_PICTURE
    ../EMWIN/EMWIN_PICTURE/BMP/: bmpdisplay.c
    ../EMWIN/EMWIN_PICTURE/GIF/: gifdisplay.c
    ../EMWIN/EMWIN_PICTURE/JPEG/: jpegdisplay.c
    ../EMWIN/EMWIN_PICTURE/PNG/: pngdisplay.c
  group EMWINPNG_LIB
    ../EMWIN/STemWinPNG/: adler32.c compress.c crc32.c deflate.c GUI_PNG.c IMAGE_PNG.c infback.c inffast.c inflate.c inftrees.c png.c pngerror.c pngget.c pngmem.c pngpread.c pngread.c pngrio.c pngrtran.c pngrutil.c pngset.c pngtrans.c pngwio.c pngwrite.c pngwtran.c pngwutil.c trees.c uncompr.c zutil.c
  group EMWIN_PAD
    ../EMWIN/KEYPAD/: keypad.c
  group EMWIN_APP
    ../EMWIN/tsst/: iconbmp.c icondemo.c backgroud.c buttonbmp.c document.c filewindow.c led_beep.c picture_app.c use_app.c
software components: CMSIS:CORE 4.3.0
